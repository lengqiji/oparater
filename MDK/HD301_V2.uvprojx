# Keil uVision project HD301_V2.uvprojx, settings and files
target HC32F460KETA_Release (6230000::V6.23::ARMCLANG)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HD301_V2 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: $P\..\..\tools\gen_rnupd.bat $P
  c flags: Optim=3 oTime=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HC32F460,ARM_MATH_CM4
  c include: ..\hd_common;..\task;..\driver\inc;..\bsp;..\iap;..\ucosii\ARM-Cortex-M4;..\ucosii\SOURCE;..\ucosii\config;..\include;..\module;..\base;..\SEGGER_RTT_V770c\RTT;..\fun;..\motor
  library: MicroLIB
  memory RVCT4: ROM 0xa000 size 0x7e000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group hd_common
    ../hd_common/: startup_hc32f460.s system_hc32f460.c
  group ucos
    ../ucosii/ARM-Cortex-M4/: os_cpu_a.asm os_cpu_c.c
    ../ucosii/SOURCE/: ucos_ii.c
  group task
    ../task/: main.c Task_Status.c Task_Status.h Task_Cmd.c Task_Main.c Task_Test.c Task_Motor.c
  group driver
    ../driver/src/: hc32f460_spi.c hc32f460_adc.c hc32f460_aes.c hc32f460_can.c hc32f460_clk.c hc32f460_cmp.c hc32f460_crc.c hc32f460_dcu.c hc32f460_dmac.c hc32f460_efm.c hc32f460_emb.c hc32f460_event_port.c hc32f460_exint_nmi_swi.c hc32f460_gpio.c hc32f460_hash.c hc32f460_i2c.c hc32f460_i2s.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_keyscan.c hc32f460_mpu.c hc32f460_ots.c hc32f460_pwc.c hc32f460_qspi.c hc32f460_rmu.c hc32f460_rtc.c hc32f460_sdioc.c hc32f460_sram.c hc32f460_swdt.c hc32f460_timer0.c hc32f460_timer4_cnt.c hc32f460_timer4_emb.c hc32f460_timer4_oco.c hc32f460_timer4_pwm.c hc32f460_timer4_sevt.c hc32f460_timer6.c hc32f460_timera.c hc32f460_trng.c hc32f460_usart.c hc32f460_utility.c hc32f460_wdt.c
    ../driver/inc/: hc32f460_adc.h hc32f460_aes.h hc32f460_can.h hc32f460_clk.h hc32f460_cmp.h hc32f460_crc.h hc32f460_dcu.h hc32f460_dmac.h hc32f460_efm.h hc32f460_emb.h hc32f460_event_port.h hc32f460_exint_nmi_swi.h hc32f460_gpio.h hc32f460_hash.h hc32f460_i2c.h hc32f460_i2s.h hc32f460_icg.h hc32f460_interrupts.h hc32f460_keyscan.h hc32f460_mpu.h hc32f460_ots.h hc32f460_pwc.h hc32f460_qspi.h hc32f460_rmu.h hc32f460_rtc.h hc32f460_sdioc.h hc32f460_spi.h hc32f460_sram.h hc32f460_swdt.h hc32f460_timer0.h hc32f460_timer4_cnt.h hc32f460_timer4_emb.h hc32f460_timer4_oco.h hc32f460_timer4_pwm.h hc32f460_timer4_sevt.h hc32f460_timer6.h hc32f460_timera.h hc32f460_trng.h hc32f460_usart.h hc32f460_utility.h hc32f460_wdt.h
  group bsp
    ../bsp/: bsp.c bsp.h bsp_adc.c bsp_gpio.c bsp_motor.c bsp_motor_current.c bsp_can.c bsp_flash.c bsp_flash_new.c bsp_clock.c bsp_qf.c bsp_thread.c bsp_lock.c bsp_fault.c bsp_wdt.c bsp_uart.c
  group module
    ../module/: module.c cmd.c qf.c led.c stepper_motor.c
  group base
    ../base/: para.c alarm.c
  group SEGGER_RTT
    ../SEGGER_RTT_V770c/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
  group cmd
    ../task/cmd/: cmd_process.c cmd_work.c cmd_main.c cmd_ext.c cmd_params.c cmd_rst.c cmd_update.c cmd_addr.c cmd_factoryTest.c
  group fun
    ../fun/: signal_led.c key.c thread_check.c lock.c hook_motor.c jump_motor.c address.c rn_test_byModbus.c footLock_motor.c factory_test.c
software components: CMSIS:CORE 5.5.0
